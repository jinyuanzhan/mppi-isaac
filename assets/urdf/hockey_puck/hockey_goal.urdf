Commit message: add fixed based franka files for hocky puck task

File: assets/urdf/hockey_puck/hockey_goal.urdf (robot description, URDF)
Before this commit: robot hockey_goal_with_net, 2 links, 1 joints
Links:
- link goal_net: geometry visual mesh filename=soccer_net.stl scale=2.33 2.0 1.93
